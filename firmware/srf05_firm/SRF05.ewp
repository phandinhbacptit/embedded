# IAR project SRF05.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: C:\Users\phandinhbac\Dropbox\VROBOX\Sourcode\embedded\firmware\srf05_firm; C:\Users\phandinhbac\Dropbox\VROBOX\Sourcode\embedded\firmware\srf05_firm\Libraries\my_library\inc; C:\Users\phandinhbac\Dropbox\VROBOX\Sourcode\embedded\firmware\srf05_firm\Libraries\my_library\src; C:\Users\phandinhbac\Dropbox\VROBOX\Sourcode\embedded\firmware\srf05_firm\Libraries\STM8S_StdPeriph_Driver\src; C:\Users\phandinhbac\Dropbox\VROBOX\Sourcode\embedded\firmware\srf05_firm\Libraries\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: SRF05.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group my_library
    Libraries/my_library/src/: control.c timer_conf.c usart_conf.c
  group standard_library
    Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
