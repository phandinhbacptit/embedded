<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SRF05.ewp</path>
    </project>
    <project>
        <path>C:\Users\TATDAT\Desktop\srf05\srf05.ewp</path>
    </project>
    <batchBuild />
</workspace>
